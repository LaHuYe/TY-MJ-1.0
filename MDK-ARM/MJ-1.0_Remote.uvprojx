# Keil uVision project MJ-1.0_Remote.uvprojx, settings and files
target Waist_Massager (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.7
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WL_MJ_TX_1.0 +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5,FLASH_OPTR_IWDG_STOP
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F002B_HAL_Driver\Inc;..\Core;..\Drivers\BSP\PY32F002Bxx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ../Src/: main.c py32f002b_it.c py32f002b_hal_msp.c application.c radio.c cmt2300a_hal.c cmt2300a.c cmt_spi3.c
  group Core
    ../Core/: tim.c key.c key_manager.c iwdg.c led.c led_manager.c addr_tx.c encoder.c adc.c bat.c common.c pwr_stop.c
  group Common
    ../Src/: system_py32f002b.c
    ./: startup_py32f002bxx.s
  group PY32F030xx_HAL_Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_cortex.c py32f002b_hal_exti.c py32f002b_hal_gpio.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_flash.c
  group PY32F030xx_Start_Kit
    ../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_Start_Kit.c
