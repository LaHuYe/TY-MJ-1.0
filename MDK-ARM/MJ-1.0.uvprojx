# Keil uVision project MJ-1.0.uvprojx, settings and files
target MJ-1.0 (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MJ-1.0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Core;..\Drivers\BSP\PY32F030xx_Start_Kit;..\BLDC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../Src/: main.c py32f0xx_it.c py32f0xx_hal_msp.c application.c
    ../Core/: common.c
  group Core
    ../Core/: adc.c tim.c key.c key_manager.c led.c led_manager.c bat.c power_control.c pwr_stop.c
  group BLDC
    ../BLDC/: bldc_app.c bldc_comp.c bldc_motor.c bldc_init.c
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f030xx.s
  group PY32F030xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal_adc.c py32f0xx_hal_exti.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_uart.c py32f0xx_hal_tim.c py32f0xx_hal_iwdg.c py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_tim_ex.c py32f0xx_hal_flash.c py32f0xx_hal_lptim.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_comp.c
  group PY32F030xx_Start_Kit
    ../Drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_Start_Kit.c
